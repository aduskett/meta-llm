SUMMARY = "Local LLM models"
DESCRIPTION = "Start building with open models. Access the latest releases locally or in the cloud with complete privacy."
HOMEPAGE = "https://ollama.com"
BUGTRACKER = "https://github.com/ollama/ollama/issuess"
CVE_PRODUCT = "ollama"
SECTION = "devtools"

LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=a8abe7311c869aba169d640cf367a4af"

SRC_URI = "git://github.com/ollama/ollama;protocol=https;branch=main;tag=v${PV}"



